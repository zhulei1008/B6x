# Keil uVision project iwdt_em_acc_failed.uvprojx, settings and files
target iwdt_em_acc_failed (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: iwdt_em_acc_failed +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMW500_BQB
  c misc: --c99 --gnu --thumb --bss_threshold=0  --preinclude=..\src\rf_cfg.h  --preinclude=..\src\cfg.h
  c include: ..\src;..\src\bb_em;..\src\rf_func;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm define: CACHE_USE_SRAM
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_sram.sct
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group debug
    ../../../modules/src/: debug.c
