# Keil uVision project burner.uvprojx, settings and files
target burner (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: burnerC +hex
  AfterMake: fromelf --bin --output ".\output\@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99 --thumb -c --bss_threshold=0 --diag_suppress=1 --preinclude=..\src\burner\cfg.h
  c include: ..\..\..\..\core;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\src;..\src\burner;..\src\protocol;..\src\test_rf;..\src\test_rf\inc;..\src\test_gpio;..\src\test_pwr;..\src\test_xtal;..\src\program;..\src\burner;..\..\..\..\usb\api;..\..\..\..\usb\class\cdc;..\src\device\api;..\..\..\..\usb\class\hid;..\src\test_trim
  library: MicroLIB
  scatter file: ..\..\..\..\core\mdk\link_sram.sct
  group main
    ../src/burner/: cfg.h main.c burner.c chipfirm.c chiptest.c
  group protocol
    ../src/protocol/: proto.h proto.c proto_cmd.c proto_rsp.c pt_env.h pt_pkt.c pt_sch.c uart_itf.h uart1_itf.c uart2_itf.c usbd_itf.c usb2hid_itf.c
    ../src/burner/: burner.h
  group test
    ../src/test_rf/: rf_test.c rf_utils.c
    ../src/test_pwr/: pwr_test.c
    ../src/test_xtal/: xtal_test.c
    ../src/test_gpio/: gpio_test.c
  group device
    ../src/device/: btns.c leds.c sftmr.c
  group core
    ../../../../core/mdk/: startup.s
  group libs
    ../../../../drivers/lib/: drvs.lib
    ../../../../drivers/src/: uart.c
  group program
    ../src/program/: prg_api.h prg_flash.c prg_otp.c
  group usbd
    ../../../../usb/api/: usbd.h
    ../../../../usb/lib/: usbd.lib
    ../../../../usb/class/hid/: usbd_hid.c
    ../../../../usb/class/cdc/: usbd_cdc.c
