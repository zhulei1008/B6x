# Keil uVision project chipset.uvprojx, settings and files
target chipset (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: IRAM(0x20000000,0x5000) IRAM2(0x20005000,0x2000) IROM(0x00000000,0x01000) IROM2(0x00000000,0x02000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: chipset_F +hex
  AfterMake: fromelf --bin --output ".\output\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99 --thumb -c --bss_threshold=0 --diag_suppress=1 --preinclude=..\src\chipset\cfg.h
  c include: ..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\drivers\src;..\..\..\device\api;..\src;..\src\chipset;..\src\protocol;..\src\test_rf;..\src\test_rf\inc;..\src\test_gpio;..\src\test_pwr;..\src\test_xtal;..\src\program
  asm include: C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT5: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x20005000 size 0x2000
  scatter file: ..\..\..\core\mdk\link_xip.sct
  group main
    ../src/chipset/: cfg.h main.c chipset.c Trace.c
  group protocol
    ../src/protocol/: proto.h proto.c proto_cmd.c proto_rsp.c pt_env.h pt_pkt.c pt_sch.c uart_itf.h uart1_itf.c uart2_itf.c
  group test
    ../src/test_rf/: rf_test.c rf_utils.c
    ../src/test_gpio/: gpio_test.c
    ../src/test_xtal/: xtal_test.c
    ../src/test_pwr/: pwr_test.c
    ../src/test_trim/: trim_test.c
  group device
    ../src/device/: sftmr.c
  group core
    ../../../../core/mdk/: startup.s
  group libs
    ../../../../drivers/lib/: drvs.lib
    ../../../../drivers/src/: sadc.c
  group program
    ../src/program/: prg_flash.c
target chipset_Sram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: as above
  output: chipsetC_QFN +hex
  AfterMake: fromelf.exe  --bin -o ".\output\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CHIPSRAM
  c misc: as above
  c include: ..\..\..\..\core;..\..\..\..\core\reg;..\..\..\..\drivers\api;..\..\..\..\drivers\src;..\..\..\..\device\api;..\..\..\..\usb\class\cdc;..\src;..\src\chipset;..\src\protocol;..\src\test_rf;..\src\test_rf\bb_em;..\src\test_gpio;..\src\test_pwr;..\src\test_xtal;..\src\program;..\src\device\api;..\src\test_trim
  asm include: C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT5: ROM 0x91d size 0x5b26
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x20005000 size 0x2000
  scatter file: ..\..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
target chipset_Sram_SOP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: as above
  output: chipsetC_SOP +hex
  AfterMake: fromelf.exe  --bin -o ".\output\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CHIPSRAM, SOP
  c misc: as above
  c include: as above
  asm include: C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT5: ROM 0x91d size 0x5b26
  memory RVCT9: RAM 0x20000000 size 0x5000
  memory RVCT10: RAM 0x20005000 size 0x2000
  scatter file: ..\..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
