# Keil uVision project batch.uvprojx, settings and files
target batch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: batch +hex
  AfterMake: fromelf --bin --output ".\output\@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb -c --bss_threshold=0 --diag_suppress=1 --preinclude=..\src\batch\cfg.h
  c include: ..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\src;..\src\batch;..\src\program;..\src\protocol;..\src\device\api;..\src\display;..\src\test_rf;..\src\test_rf\inc;..\src\burner;..\src\test_xtal;..\src\test_gpio
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_xip.sct
  group main
    ../src/batch/: cfg.h main.c batch.c chans.c chanfirm.c
  group protocol
    ../src/protocol/: proto.c proto_cmd.c proto_rsp.c pt_pkt.c pt_sch.c uart1_itf.c uart2_itf.c
  group device
    ../src/device/: sftmr.c led.c btn.c beep.c
  group dispaly
    ../src/display/: display.c oled_api.c oled_font.c
  group core
    ../../../core/mdk/: startup.s
  group libs
    ../../../drivers/lib/: drvs.lib
  group program
    ../src/program/: prg_flash.c
