# Keil uVision project bleUart_USB.uvprojx, settings and files
target bleUart_USB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: bleUart_USB_FPGA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\..\..\usb\api;..\..\..\usb\class\cdc;..\..\..\usb\class\hid
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
  group core
    ../src/: startup.s
  group src
    ../src/: cfg.h main.c myapp.c proc.c fpga_spi_rf.c usb_demo.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: uart1Rb.c leds.c sftmr.c
  group ble\app
    ../../../ble/app/: app.c app_prf.c app_msg.c app_gapm.c app_gapc.c
    ../src/: app_actv.c
  group ble\prf
    ../../../ble/prf/: prf_sess.c
  group ble\lib
    ../../../ble/lib/: ble6_fw.lib ble6.lib BLE6_EM_0x20008400.lib BLE6_ADV_Interval_10ms.lib
    ../../../drivers/lib/: drvs.lib
  group usbd
    ../../../usb/api/: usbd.h
    ../../../usb/lib/: usbd.lib
    ../../../usb/class/hid/: usbd_hid.c
  group debug
    ../../../modules/src/: debug.c
