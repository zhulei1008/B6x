<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\bistTest\mdk\bistTest.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\bleUart_FPGA\mdk\bleUart_FPGA.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>.\bleUart_USB\mdk\bleUart_USB.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\flashTest\mdk\flashTest.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\iwdtTest\mdk\iwdtTest.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\pwroffTest\mdk\pwroffTest.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\jumpTest\mdk\jumpTest.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\xmemTest\mdk\xmemTest.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
