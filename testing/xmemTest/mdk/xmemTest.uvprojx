# Keil uVision project xmemTest.uvprojx, settings and files
target xmemTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: xmemTest +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
  group core
    ../src/: startup.s
  group src
    ../src/: cfg.h main.c xapi.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group debug
    ../../../modules/src/: debug.c
target xmemTest_sram_api (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: xmemTest +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
