# Keil uVision project rf_mod.uvprojx, settings and files
target ble_2g4_bqb_uart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: ble_2g4 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CMW500_BQB
  c misc: --c99 --gnu --thumb --bss_threshold=0  --preinclude=..\src\rf_cfg.h  --preinclude=..\src\cfg.h
  c include: ..\src;..\src\bb_em;..\src\rf_func;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm define: CACHE_USE_SRAM
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\..\..\core\mdk\link_sram.sct
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c bqb_proc.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: uart1Rb.c uart2Rb.c
  group rf_func
    ../src/rf_func/: rf_test.c rf_utils.c
  group debug
    ../../../modules/src/: debug.c
target ble_2g4_bqb_uart_flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: ble_2g4 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_CODE, SUPPORT_QUAD, CMW500_BQB, FLASH_CODE, NO_CACHE
  c misc: as above
  c include: ..\src;..\src\bb_em;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\..\..\core\mdk\link_xip.sct
