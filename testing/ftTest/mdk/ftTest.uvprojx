# Keil uVision project ftTest.uvprojx, settings and files
target b6xFtTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: ftTest +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_CODE, SUPPORT_DUAL, ROM_DRVS
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\mdk;..\..\..\core\reg;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\profiles;..\src\clock;..\src\gpio;..\src\lowpower;..\src\rf\include;..\src\trim;..\src\rf;..\src\rf\inc;..\src\mbist;..\src\digital;..\..\..\modules\api;..\..\..\drivers\api;..\src\rf\bb_em
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\..\..\core\mdk\link_sram.sct
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c ft_test.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
    ../../../../rom/hexmif/: b6x_rom.symdef
  group debug
    ../../../modules/src/: debug.c
  group test
    ../src/rf/: rf_test.c rf_utils.c
    ../src/gpio/: ft_gpio.c
    ../src/trim/: ft_trim.c
    ../src/lowpower/: ft_lowpower.c
    ../src/clock/: ft_clock.c
    ../src/mbist/: ft_bist.c
    ../src/digital/: ft_digital.c
