# Keil uVision project bleUart_FPGA.uvprojx, settings and files
target bleUart (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: bleUart_FPGA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
  group core
    ../src/: startup.s
  group src
    ../src/: cfg.h main.c myapp.c proc.c fpga_spi_rf.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: leds.c sftmr.c uart1Rb.c
  group ble\app
    ../../../ble/app/: app.c app_prf.c app_msg.c app_gapm.c app_gapc.c
    ../src/: app_actv.c
  group ble\prf
    ../../../ble/prf/: prf_sess.c
  group ble\lib
    ../../../ble/lib/: ble6_fw.lib ble6.lib BLE6_EM_0x20008400.lib BLE6_ADV_Interval_10ms.lib
  group debug
    ../../../modules/src/: debug.c
target bleUart_fw (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bleUart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
target bleUart_NoMag (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bleUart_FPGA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
target bleUart_Mag1000 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bleUart_FPGA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
target bleUart_Mag1000_EM_0x20008400 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bleUart_FPGA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: RAM_CODE, SUPPORT_QUAD,  FLASH_CODE, EM_0x20008400
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\src\link_xip.sct
  link misc: --diag_suppress=L6314,L6329
