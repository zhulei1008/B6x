# Keil uVision project rf_pll_unlock.uvprojx, settings and files
target rf_afe_xip (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: IRAM(0x20000000,0x5000) IRAM2(0x20005000,0x2000) IROM(0x00000000,0x01000) IROM2(0x00000000,0x02000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: rf_afe +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  memory RVCT5: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20003000 size 0x5000
  memory RVCT10: RAM 0x20005000 size 0x2000
  scatter file: ..\..\..\core\mdk\link_xip.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c uart_cmd.c rf_afe.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group debug
    ../../../modules/src/: debug.c
target rf_afe_sram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: rf_afe +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: as above
  c include: as above
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\..\..\core\mdk\link_sram.sct
  link misc: --diag_suppress=L6312,L6314,L6329
