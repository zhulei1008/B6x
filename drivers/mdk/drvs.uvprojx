# Keil uVision project drvs.uvprojx, settings and files
target drvsLib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: CPUTYPE("Cortex-M0+") CLOCK(16000000) ESEL ELITTLE
  output: drvs (library)
  BeforeMake: .\get_svn_ver.bat
  AfterMake: cmd.exe /C copy  "#L"  "$P..\lib"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __NO_EMBEDDED_ASM
  c misc: --gnu --thumb --bss_threshold=0
  c include: ..\api;..\src;..\..\core;..\..\core\reg
  link misc: --any_placement=best_fit --datacompressor=off
  group api
    ../api/: drvs.h core.h rcc.h rtc.h rco.h iwdt.h iopad.h gpio.h fshc.h flash.h exti.h dma.h timer.h pwm.h i2c.h spi.h uart.h sadc.h sysdbg.h svn_ver.h
  group src
    ../src/: core.c rcc.c rtc.c rco.c iwdt.c iopad.c exti.c dma.c timer.c pwm.c i2c.c spi.c uart.c sadc.c sysdbg.c trim.c gfsk.c fshc.c build.c
  group rtt
    ../src/RTT/: RTT.c RTT.h RTT_Conf.h Trace.c
