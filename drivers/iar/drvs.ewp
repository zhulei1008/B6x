# IAR project drvs.ewp, settings and files
configuration b6x (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa050, Pa089
  ICCARM.CCIncludePath2: ..\..\core; ..\..\core\reg; ..\src; ..\api
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd.exe /C copy output\*.a ..\lib
  ILINK.IlinkOutputFile: Driver.out
  group driverLib/RTT
    ../src/RTT/: RTT.c RTT.h RTT_Conf.h
  group driverLib/src
    ../src/: aon.c btmr.c cache.c iopad.c desc.c dma.c endpoint.c endpoint0.c exti.c fifo.c flash.c fshc.c musbfsfc.c pwc.c pwm.c rc_calib.c rcc.c reset.c rtc.c trim.c uart.c
  group release
    ../: release.txt
