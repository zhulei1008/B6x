# Keil uVision project QKIE_Mouse_SOP16.uvprojx, settings and files
target QKIE_Mouse_SOP16 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: QKIE_Mouse_SOP16_EMI_20231227 +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\src\link_xip_blelite.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h user_api.h main.c proc.c batt.c mouse.c hid_desc.c EMI_TEST.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../src/: leds.c
    ../../../modules/src/: sftmr.c
  group ble\app
    ../src/: app.c app_actv.c app_msg.c app_gapc.c
    ../../../ble/app/: app_gapm.c
  group ble\prf
    ../src/: prf_diss.c prf_bass.c prf_hids.c
  group ble\lib
    ../src/: ble6_lite_qkie.lib
  group debug
    ../../../modules/src/: debug.c
