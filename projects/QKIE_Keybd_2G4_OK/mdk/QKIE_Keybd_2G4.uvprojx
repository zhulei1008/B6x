# Keil uVision project QKIE_Keybd_2G4.uvprojx, settings and files
target QKIE_Keybd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: QKIE_Keybd_2G4
  AfterMake: powershell -executionpolicy Unrestricted -file .\link_high_bank.PS1
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf;..\ota\protocol;..\ota\chipset;..\ota\program
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\src\link_xip_blelite_0x04000.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group src
    ../src/: cfg.h user_api.h main.c myapp.c batt.c proc.c keyboard.c hid_desc.c EMI_TEST.c
  group core
    ../../../core/mdk/: startup.s
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../src/: leds.c sftmr.c
  group ble\app
    ../src/: app.c app_actv.c app_msg.c app_gapm.c app_gapc.c app_gatt.c
  group ble\prf
    ../src/: prf_diss.c prf_bass.c prf_hids.c prf_otas.c
  group ble\lib
    ../../../ble/lib/: ble6_lite.lib
  group debug
    ../../../modules/src/: debug.c
  group ota
    ../ota/chipset/: chipset.c
    ../ota/protocol/: ota_itf.c proto.c proto_rsp.c pt_pkt.c pt_sch.c
    ../ota/program/: prg_flash.c
