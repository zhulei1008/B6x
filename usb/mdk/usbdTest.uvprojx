# Keil uVision project usbdTest.uvprojx, settings and files
target usbdTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: usbdTest +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --c99 --gnu --thumb --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\core;..\..\core\reg;..\..\drivers\api;..\..\modules\api;..\api;..\usbd;..\class\cdc;..\class\hid
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\..\core\mdk\link_sram.sct
  group core
    ../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c demo_cdc_uart.c demo_hid_boot.c demo_hid_custom.c
  group drivers
    ../../drivers/api/: drvs.h
    ../../drivers/lib/: drvs.lib
  group debug
    ../../modules/src/: debug.c
  group usb\usbd
    ../api/: usbd.h
    ../lib/: usbd.lib
    ../usbd/: usbd_core.c usbd_drvs.c
  group usb\class
    ../class/cdc/: usbd_cdc.c
    ../class/hid/: usbd_hid.c
