# Keil uVision project usbd.uvprojx, settings and files
target usbd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(16000000) ESEL ELITTLE
  output: usbd +hex (library)
  AfterMake: cmd.exe /C copy  "#L"  "$P..\lib"
  c flags: uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --c99 --gnu --thumb --bss_threshold=0
  c include: ..\src;..\..\core;..\..\core\reg;..\..\drivers\api;..\..\modules\api;..\api;..\usbd;..\class\audio;..\class\cdc;..\class\dfu;..\class\hid;..\class\hub;..\class\midi;..\class\msc;..\class\mtp;..\class\printer;..\class\tmc;..\class\vendor;..\class\video;..\class\wireless
  asm misc: --thumb
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20003000 size 0x20000
  scatter file: ..\..\core\mdk\link_xip.sct
  group usbd\core
    ../usbd/: usbd_core.c usbd_drvs.c usbd_int.h reg_usb.h
    ../api/: usbd.h
  group usbd\class
    ../class/cdc/: usbd_cdc.c
    ../class/hid/: usbd_hid.c
